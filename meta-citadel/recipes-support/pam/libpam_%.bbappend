FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://pam.d/common-auth"
