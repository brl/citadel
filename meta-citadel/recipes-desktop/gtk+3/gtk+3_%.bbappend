FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://gtk-update-icon-cache-reproducibility-fix.patch"
