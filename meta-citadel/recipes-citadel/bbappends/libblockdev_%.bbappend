
PACKAGECONFIG = "fs crypto parted mdraid tools"
DEPENDS += "systemd"
