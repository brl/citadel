RDEPENDS:pulseaudio-server:remove = "pulseaudio-module-console-kit"
RDEPENDS:remove = "pulseaudio-module-x11-cork-request \
                pulseaudio-module-x11-publish \
                pulseaudio-module-x11-xsmp \
"
PACKAGECONFIG:remove = "x11"
