PACKAGECONFIG = "nm alsa gudev wayland"
EXTRA_OEMESON += " -Dwwan=false"
