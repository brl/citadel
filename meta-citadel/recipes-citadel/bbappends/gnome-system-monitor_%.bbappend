RRECOMMENDS:${PN}:remove = "adwaita-icon-theme"
